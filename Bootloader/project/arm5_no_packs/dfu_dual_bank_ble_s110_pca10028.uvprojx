# Keil uVision project dfu_dual_bank_ble_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x0003C000,0x3C00) IRAM(0x20002000,0x6000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF51
  c misc: --c99
  c include: ..\..\src\;..\..\src\config;D:\Develop\SDK\nrf51_10.0.0\components\toolchain;D:\Develop\SDK\nrf51_10.0.0\components\ble\ble_services\ble_dfu;D:\Develop\SDK\nrf51_10.0.0\components\ble\common;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\delay;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\hal;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\pstorage;D:\Develop\SDK\nrf51_10.0.0\components\libraries\bootloader_dfu;D:\Develop\SDK\nrf51_10.0.0\components\libraries\bootloader_dfu\ble_transport;D:\Develop\SDK\nrf51_10.0.0\components\libraries\crc16;D:\Develop\SDK\nrf51_10.0.0\components\libraries\hci;D:\Develop\SDK\nrf51_10.0.0\components\libraries\scheduler;D:\Develop\SDK\nrf51_10.0.0\components\libraries\timer;D:\Develop\SDK\nrf51_10.0.0\components\libraries\util;D:\Develop\SDK\nrf51_10.0.0\components\softdevice\common\softdevice_handler;D:\Develop\SDK\nrf51_10.0.0\components\softdevice\s110\headers;D:\Develop\SDK\nrf51_10.0.0\examples\bsp
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
  group Application
    ../../src/: dfu_ble_svc.c main.c
  group nRF_BLE
    D:/Develop/SDK/nrf51_10.0.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    D:/Develop/SDK/nrf51_10.0.0/components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/delay/: nrf_delay.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/pstorage/: pstorage_raw.c
  group nRF_Libraries
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/util/: app_error.c nrf_assert.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/scheduler/: app_scheduler.c
    ../../src/: app_timer.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/timer/: app_timer_appsh.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/bootloader_dfu/: bootloader.c bootloader_settings.c bootloader_util.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/crc16/: crc16.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/hci/: hci_mem_pool.c
  group nRF_SoftDevice
    D:/Develop/SDK/nrf51_10.0.0/components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    D:/Develop/SDK/nrf51_10.0.0/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
