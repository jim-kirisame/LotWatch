# Keil uVision project ble_app_template_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\src;..\..\src\config;D:\Develop\SDK\nrf51_10.0.0\components\device;D:\Develop\SDK\nrf51_10.0.0\examples\bsp;D:\Develop\SDK\nrf51_10.0.0\components\toolchain;D:\Develop\SDK\nrf51_10.0.0\components\ble\ble_advertising;D:\Develop\SDK\nrf51_10.0.0\components\ble\common;D:\Develop\SDK\nrf51_10.0.0\components\ble\device_manager;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\common;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\delay;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\gpiote;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\config;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\hal;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\pstorage;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\uart;D:\Develop\SDK\nrf51_10.0.0\components\libraries\button;D:\Develop\SDK\nrf51_10.0.0\components\libraries\timer;D:\Develop\SDK\nrf51_10.0.0\components\libraries\trace;D:\Develop\SDK\nrf51_10.0.0\components\libraries\uart;D:\Develop\SDK\nrf51_10.0.0\components\libraries\util;D:\Develop\SDK\nrf51_10.0.0\components\libraries\hci;D:\Develop\SDK\nrf51_10.0.0\components\softdevice\common\softdevice_handler;D:\Develop\SDK\nrf51_10.0.0\components\softdevice\s110\headers;D:\Develop\SDK\nrf51_10.0.0\components\libraries\bootloader_dfu;D:\Develop\SDK\nrf51_10.0.0\components\ble\ble_services\ble_dfu;D:\Develop\SDK\nrf51_10.0.0\components\ble\ble_services\ble_bas;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\spi_master;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\rtc;D:\Develop\SDK\nrf51_10.0.0\components\drivers_nrf\clock;D:\Develop\SDK\nrf51_10.0.0\components\libraries\scheduler
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../src/: main.c dfu_app.c bas_app.c ssd1306_app.c charge_app.c mma8452.c temp_app.c rtc_app.c key_app.c app_page.c disp_app.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    D:/Develop/SDK/nrf51_10.0.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    D:/Develop/SDK/nrf51_10.0.0/components/ble/ble_advertising/: ble_advertising.c
    D:/Develop/SDK/nrf51_10.0.0/components/ble/device_manager/: device_manager_peripheral.c
    D:/Develop/SDK/nrf51_10.0.0/components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/uart/: app_uart.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/delay/: nrf_delay.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/common/: nrf_drv_common.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/uart/: nrf_drv_uart.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/pstorage/: pstorage.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/hal/: nrf_adc.c
    D:/Develop/SDK/nrf51_10.0.0/components/ble/ble_services/ble_bas/: ble_bas.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../src/: twi_sw_master.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/rtc/: nrf_drv_rtc.c
    D:/Develop/SDK/nrf51_10.0.0/components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF_Libraries
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/button/: app_button.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/util/: app_error.c nrf_assert.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/timer/: app_timer.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/trace/: app_trace.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/uart/: retarget.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/bootloader_dfu/: dfu_app_handler.c bootloader_util.c
    D:/Develop/SDK/nrf51_10.0.0/components/libraries/scheduler/: app_scheduler.c
  group nRF_SoftDevice
    D:/Develop/SDK/nrf51_10.0.0/components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    D:/Develop/SDK/nrf51_10.0.0/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s110_nrf51_8.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: s110_nrf51_8.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: ..\..\..\config;D:\Develop\SDK\nrf51_10.0.0\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
